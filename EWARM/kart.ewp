# IAR project kart.ewp, settings and files
configuration kart (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L5xx_HAL_Driver/Inc; ../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure; ../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../Drivers/CMSIS/Include; ..\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: kart.hex
  ILINK.IlinkOutputFile: kart.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/flight_controller
    ../Src/flight_controller/: flight_controller_api.h flight_controller_config.h
  group Application/flight_controller/src
    ../Src/flight_controller/src/: flight_controller_api.c flight_controller_conductor.c flight_controller_conductor.h flight_controller_driver.c flight_controller_driver.h flight_controller_hdwr.c flight_controller_hdwr.h
  group Application/hdwr
    ../Src/hdwr/: adc_api.h fifo_api.h gpio_api.h pwm_api.h spi_api.h
  group Application/hdwr/src
    ../Src/hdwr/src/: adc_api.c fifo_api.c gpio_api.c pwm_api.c spi_api.c
  group Application/heartbeat
    ../Src/heartbeat/: heartbeat_api.h
  group Application/heartbeat/src
    ../Src/heartbeat/src/: heartbeat_api.c
  group Application/log
    ../Src/log/: log_api.h log_config.h
  group Application/log/src
    ../Src/log/src/: log_api.c log_conductor.c log_conductor.h log_driver.c log_driver.h log_hdwr.c log_hdwr.h
  group Application/periodic
    ../Src/periodic/: periodic_api.h periodic_config.h
  group Application/periodic/src
    ../Src/periodic/src/: periodic_api.c periodic_conductor.c periodic_conductor.h periodic_driver.c periodic_driver.h
  group Application/system
    ../Src/system/: system_api.h
  group Application/system/src
    ../Src/system/src/: system_api.c system_obj.c system_obj.h
  group Application/User
    ../Src/: app_freertos.c main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
